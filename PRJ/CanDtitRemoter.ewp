# IAR project CanDtitRemoter.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\LIB\STM8L15x_StdPeriph_Driver\inc; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: CanDtitRemoter.hex
  ILINK.IlinkOutputFile: CanDtitRemoter.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l151k4.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group LIB
    ../LIB/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_usart.c
  group USER
    ../USER/: eeprom.c FireLamp.c LightPwmDrv.c main.c NvramOp.c stm8l15x_it.c UartDev.c
